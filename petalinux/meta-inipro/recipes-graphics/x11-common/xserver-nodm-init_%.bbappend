pkg_postinst_ontarget_${PN} () {
        rm /etc/rc5.d/S*xserver-nodm
}
