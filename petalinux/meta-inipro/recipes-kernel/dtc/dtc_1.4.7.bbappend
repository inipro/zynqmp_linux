FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Kill-bogus-TYPE_BLOB-marker-type.patch"

