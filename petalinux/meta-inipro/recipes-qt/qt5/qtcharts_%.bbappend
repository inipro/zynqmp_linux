INSANE_SKIP_${PN} += "host-user-contaminated"
